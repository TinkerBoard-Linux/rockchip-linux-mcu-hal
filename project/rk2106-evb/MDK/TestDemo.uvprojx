# Keil uVision project TestDemo.uvprojx, settings and files
target RK2106 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TestDemo
  c flags: wLevel=1
  c include: ..\src;..\..\..\lib\hal\inc;..\..\..\lib\CMSIS\Include;..\..\..\lib\CMSIS\Device\RK2106\Include;..\..\..\lib\CMSIS\Device
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x5000
  memory RVCT9: RAM 0x3050000 size 0x4000
  scatter file: ..\..\..\lib\CMSIS\Device\RK2106\Source\Templates\ARM\ARMCM3_ac5.sct
  group Device
    ../../../lib/CMSIS/Device/RK2106/Source/Templates/: system_rk2106.c
    ../../../lib/CMSIS/Device/RK2106/Source/Templates/ARM/: startup_rk2106.s
  group USER
    ../src/: bsp.c main.c
  group HAL
    ../../../lib/hal/src/: hal_base.c hal_nvic.c hal_uart.c hal_gpio.c hal_grf.c hal_timer.c hal_debug.c
